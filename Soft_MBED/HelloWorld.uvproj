# Keil uVision project HelloWorld.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: mbed
  AfterMake: fromelf --bin -o build\mbed.bin build\mbed.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TARGET_MBED_LPC1768,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1393008488.49,  __MBED__=1,
  c misc: --gnu
  c include: .; .\Lgp\mbed;.\Lgp\mbed\LPC1768; .\Lgp\mbed\LPC1768\arm; .\Lgp\Includes; .\Includes; .\ModeleMatlab\Header; .\ModeleMatlab\ModeleRobot_ert_rtw
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: Lgp/mbed/LPC1768/ARM/LPC1768.sct
  link misc: Lgp/mbed/LPC1768/ARM/sys.o
            
              Lgp/mbed/LPC1768/ARM/cmsis_nvic.o
            
              Lgp/mbed/LPC1768/ARM/system_LPC17xx.o
            
              Lgp/mbed/LPC1768/ARM/core_cm3.o
            
              Lgp/mbed/LPC1768/ARM/startup_LPC17xx.o
            
              Lgp/mbed/LPC1768/ARM/capi.ar
            
             Lgp/mbed/LPC1768/ARM/mbed.ar
  group src
    ./Sources/: CTelemetres.cpp CAsservissement.cpp CCapteurs.cpp CEcranTactile.cpp CEEPROM.cpp CGlobale.cpp CGlobale_ModeAutonome.cpp CGlobale_ModePiloteLaBotBox.cpp CGlobale_ModePiloteTerminal.cpp CMatch.cpp ConfigFile.cpp CRoues.cpp CTrameCAN.cpp CTrameEcranTactile.cpp MessagerieLaBotBox.cpp MessagerieEcranTactile.cpp MessagerieCamera.cpp RessoucesHardware.cpp main.cpp CMoteurs.cpp CTrameCamera.cpp CCamera.cpp CAsservissementSulfateuse.cpp CTrameLaBotBox.cpp CLaBotBox.cpp CServoMoteurSD20.cpp CServoMoteurAX.cpp
  group inc
    ./Includes/: CAsservissement.h CCapteurs.h CEcranTactile.h CEEPROM.h CGlobale.h CMatch.h ConfigFile.h CRoues.h CTrameCAN.h CTrameEcranTactile.h MessagerieEcranTactile.h RessourcesHardware.h CTelemetres.h MessagerieCamera.h ConfigSpecifiqueCoupe.h CMoteurs.h CAsservissementSulfateuse.h MessagerieLaBotBox.h CTrameLaBotBox.h CLaBotBox.h CServoMoteurSD20.h CServoMoteurAX.h
  group ModeleMatlab
    ./ModeleMatlab/ModeleRobot_ert_rtw/: ModeleRobot.c ModeleRobot_data.c
    ./ModeleMatlab/Header/: rt_pow.c rt_zcfcn.c
